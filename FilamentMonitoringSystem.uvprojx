# Keil uVision project FilamentMonitoringSystem.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FilamentMonitoringSystem
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
  group Libraries
    ./: ADC.c ADC.h functions.c functions.h GPIO.c GPIO.h Interrupt.c Interrupt.h PWM.c PWM.h UART.c UART.h util.c util.h IRSensor.c IRSensor.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
